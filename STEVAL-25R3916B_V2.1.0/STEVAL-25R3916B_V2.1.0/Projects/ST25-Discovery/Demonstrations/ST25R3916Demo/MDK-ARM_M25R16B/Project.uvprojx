# Keil uVision project Project.uvprojx, settings and files
target STEVAL25R3916B_M25R16B_D25R16B (6220000::V6.22::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STEVAL25R3916B_M25R16B_D25R16B +hex
  AfterMake: $J\..\bin\fromelf.exe --bin --output=..\Binary\@L.bin !L
  AfterMake: $J\..\bin\fromelf.exe --i32 --output=@L.hex !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L476xx,USE_LCD,MENU_DEMO_CENTER_ICONS=1,USE_LOGGER=1,USE_MB1749_A=1,ST25R3916B,USE_M25R16B,USE_JOYSTICKONLY
  c include: ..\Inc;..\Picture;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\..\Drivers\BSP\Components\ad5112;..\..\..\..\..\Drivers\BSP\Components\ili9341_cube;..\..\..\..\..\Drivers\BSP\ST25-Discovery;..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include;..\..\..\..\..\Middlewares\ST\menu_demo;..\..\..\..\..\Middlewares\ST\NDEF\include\message;..\..\..\..\..\Middlewares\ST\NDEF\include\poller;..\..\..\..\..\Middlewares\ST\RFAL\include;..\..\..\..\..\Middlewares\ST\RFAL\source;..\..\..\..\..\Middlewares\ST\RFAL\source\st25r3916;..\..\..\..\..\Middlewares\ST\Reader_common\firmware\STM\utils\Inc;..\..\..\..\..\Middlewares\ST\Reader_common\firmware\STM\STM32\Inc;..\..\..\..\..\Middlewares\ST\fw_3916\DISCO-STM32L4x6\Inc;..\..\..\..\..\Middlewares\ST\fw_3916\DISCO-STM32L4x6\Drivers\BSP\DISCO-STM32L4x6;..\..\..\..\..\Middlewares\ST\p2p;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;..\..\..\..\..\Utilities\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\ST25R3916Demo.sct
  link misc: --diag_suppress=L6329 --diag_suppress=L6989 --info=stack --reduce_paths
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../Src/: main.c Menu_config.c fs_api.c Menu_definition.c jpeg_decode.c stm32l4xx_hal_msp.c stm32l4xx_it.c exampleRfalPoller.c aat.c card_emulation.c p2p.c ndef_demo.c boardcheck.c jdata_conf.c usb_hid_stream_driver.c usbd_conf.c usbd_customhid_if.c usbd_desc.c usb_device.c
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/ili9341_cube/: ili9341_cube.c
    ../../../../../Drivers/BSP/Components/ad5112/: ad5112.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Middlewares/ST/fw_3916/DISCO-STM32L4x6/Src/: led.c
  group Drivers/BSP/ST25-Discovery
    ../../../../../Drivers/BSP/ST25-Discovery/: st25_discovery.c st25_discovery_dpot.c st25_discovery_lcd.c st25_discovery_ts.c st25_discovery_st25r.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Middlewares/NDEF/message
    ../../../../../Middlewares/ST/NDEF/source/message/: ndef_message.c ndef_record.c ndef_type_aar.c ndef_type_deviceinfo.c ndef_type_empty.c ndef_type_flat.c ndef_type_media.c ndef_type_text.c ndef_type_uri.c ndef_type_vcard.c ndef_types.c
  group Middlewares/NDEF/poller
    ../../../../../Middlewares/ST/NDEF/source/poller/: ndef_poller.c ndef_poller_message.c ndef_poller_rf.c ndef_t2t.c ndef_t3t.c ndef_t4t.c ndef_t5t.c ndef_t5t_rf.c
  group Middlewares/Jpeg
    ../../../../../Middlewares/Third_Party/LibJPEG/source/: jcmarker.c jcmaster.c jdcolor.c jdmaster.c jdsample.c jfdctfst.c jutils.c jccoefct.c jcsample.c jdapimin.c jidctfst.c jquant1.c jquant2.c jcinit.c jdapistd.c jctrans.c jdpostct.c jcapistd.c jcparam.c jerror.c jfdctint.c jcdctmgr.c jdmerge.c jddctmgr.c jidctint.c jdcoefct.c jdinput.c jcapimin.c jcarith.c jaricom.c jdmainct.c jidctflt.c jdarith.c jdhuff.c jcmainct.c jdatasrc.c jcprepct.c jdtrans.c jmemnobs.c jdatadst.c jchuff.c jdmarker.c jmemmgr.c jcomapi.c jfdctflt.c jccolor.c
  group Middlewares/Menu_Demo
    ../../../../../Middlewares/ST/menu_demo/: Menu_core.c Menu_cursor.c Menu_tab.c
  group Middlewares/RFAL
    ../../../../../Middlewares/ST/RFAL/source/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_t1t.c rfal_dpo.c rfal_t2t.c rfal_t4t.c rfal_st25xv.c rfal_nfc.c
  group Middlewares/RFAL/st25r3916
    ../../../../../Middlewares/ST/RFAL/source/st25r3916/: rfal_rfst25r3916.c st25r3916.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c st25r3916_aat.c
  group Middlewares/Common
    ../../../../../Middlewares/ST/Reader_common/firmware/STM/STM32/Src/: spi.c timer.c logger.c bootloader.c pac.c flash_driver.c
    ../../../../../Middlewares/ST/Reader_common/firmware/STM/utils/Src/: stream_dispatcher.c
  group Middlewares/fw_3916
    ../../../../../Middlewares/ST/fw_3916/DISCO-STM32L4x6/Src/: ce.c dispatcher.c felica.c iso14443_common.c iso14443a.c iso14443b.c iso14443b_st25tb.c nfc.c t2t.c topaz.c tuneAntenna.c kovio.c iso15693_3.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_opamp.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
  group p2p
    ../../../../../Middlewares/ST/p2p/: lib_llcp.c lib_snep.c
